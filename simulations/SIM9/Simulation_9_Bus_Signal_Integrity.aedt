$begin 'AnsoftProject'
	CreatedBy='Beevil Knievel Startup'
	Product='ElectronicsDesktop'
	$begin 'Desktop'
		Version(2025, 2)
	$end 'Desktop'
	$begin 'CircuitModel'
		Name='Simulation_9_Bus_Signal_Integrity'
		SolutionType='Circuit'
		$begin 'Design'
			Name='High_Speed_Bus_EyeDiagram'
		$end 'Design'
	$end 'CircuitModel'
$end 'AnsoftProject'
