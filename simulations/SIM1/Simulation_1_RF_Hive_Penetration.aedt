$begin 'AnsoftProject'
	CreatedBy='Beevil Knievel Startup'
	Product='ElectronicsDesktop'
	$begin 'Desktop'
		Version(2025, 2)
	$end 'Desktop'
	$begin 'HFSSModel'
		Name='Simulation_1_RF_Hive_Penetration'
		SolutionType='DrivenModal'
		$begin 'Design'
			Name='LoRa_865MHz_Hive_Antenna'
		$end 'Design'
	$end 'HFSSModel'
$end 'AnsoftProject'
