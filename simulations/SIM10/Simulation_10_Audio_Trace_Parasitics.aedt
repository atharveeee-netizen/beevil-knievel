$begin 'AnsoftProject'
	CreatedBy='Beevil Knievel Startup'
	Product='ElectronicsDesktop'
	$begin 'Desktop'
		Version(2025, 2)
	$end 'Desktop'
	$begin 'Q3DModel'
		Name='Simulation_10_Audio_Trace_Parasitics'
		SolutionType='Q3D Extractor'
		$begin 'Design'
			Name='MEMS_Mic_Audio_RLC'
		$end 'Design'
	$end 'Q3DModel'
$end 'AnsoftProject'
