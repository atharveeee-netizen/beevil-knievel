$begin 'AnsoftProject'
	CreatedBy='Beevil Knievel Startup'
	Product='ElectronicsDesktop'
	$begin 'Desktop'
		Version(2025, 2)
	$end 'Desktop'
	$begin 'Maxwell3DModel'
		Name='Simulation_5_Solar_MPPT_EMI_EMC'
		SolutionType='Magnetostatic'
		$begin 'Design'
			Name='DC_DC_Inductor_EMC'
		$end 'Design'
	$end 'Maxwell3DModel'
$end 'AnsoftProject'
